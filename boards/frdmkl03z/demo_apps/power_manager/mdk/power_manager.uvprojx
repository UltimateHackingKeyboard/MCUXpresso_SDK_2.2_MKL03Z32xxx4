# Keil uVision project power_manager.uvprojx, settings and files
target power_manager Debug (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0+")
  output: power_manager.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKL03Z32VFK4, FRDM_KL03Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../../../../platform/utilities/notifier;../../..;../../../../../devices/MKL03Z4/drivers;../../../../../devices/MKL03Z4/utilities;../../../../../devices/MKL03Z4
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKL03Z32xxx4_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKL03Z4/arm/: startup_MKL03Z4.s
    ../../../../../devices/MKL03Z4/: system_MKL03Z4.c system_MKL03Z4.h
  group doc
    ../: readme.txt
  group source
    ../: clock_mcglite.c power_manager.h power_manager.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group drivers
    ../../../../../devices/MKL03Z4/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_port.h fsl_llwu.h fsl_llwu.c fsl_pmc.h fsl_pmc.c fsl_smc.h fsl_smc.c fsl_rcm.c fsl_rcm.h fsl_lptmr.c fsl_lptmr.h fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../devices/MKL03Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
  group notifier
    ../../../../../devices/MKL03Z4/utilities/: fsl_notifier.c fsl_notifier.h
target power_manager Release (ARM-ADS)
  device: MKL03Z32xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0+")
  output: power_manager.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL03Z32VFK4, FRDM_KL03Z, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  scatter file: MKL03Z32xxx4_flash.scf
  link misc: --remove
